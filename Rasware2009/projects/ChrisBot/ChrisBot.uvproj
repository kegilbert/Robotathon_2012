# Keil uVision project ChrisBot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ChrisBot
  c flags: Optim=1
  c include: ..\..\StellarisWare;..\..\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./: Startup.s cb_main.c
  group Logic
    ./: cb_travel.c cb_travel.h
  group Drivers
    ./: cb_adc.c cb_adc.h cb_compass.c cb_compass.h cb_i2c.c cb_i2c.h cb_led.c cb_led.h cb_sonar.c cb_sonar.h cb_encoder.c cb_encoder.h cb_motor.c cb_motor.h cb_jumper.c cb_jumper.h
  group Librarys
    ../../RASLib/Debug/: raslib.lib
    ../../StellarisWare/driverlib/rvmdk/: driverlib.lib
    ../../StellarisWare/utils/: uartstdio.c
