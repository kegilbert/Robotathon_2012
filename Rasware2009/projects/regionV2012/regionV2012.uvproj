# Keil uVision project regionV2012.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: regionV2012
  c flags: Optim=1
  c include: ..\..\StellarisWare;..\..\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: travel.c charging.c ADS7830.c panel.c fan.c clock.c relays.c
  group Main
    ./: regionV2012.c Startup.s
  group Header
    ./: charging.h travel.h ADS7830.h panel.h fan.h clock.h relays.h
  group Lib
    ../../RASLib/Debug/: raslib.lib
    ../../StellarisWare/utils/: uartstdio.c
    ../../StellarisWare/driverlib/rvmdk/: driverlib.lib
