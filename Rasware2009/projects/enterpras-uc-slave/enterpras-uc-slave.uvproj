# Keil uVision project enterpras-uc-slave.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: enterpras_uc_slave
  c flags: Optim=1
  c include: ..\StellarisWare;..\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: EncoderDemo.c message_processor.c uart_functions.c nunchuck_functions.c time_functions.c motor_functions.c adc_functions.c gpio_functions.c utils.c sorted_buf.c filtering_functions.c common.c
    ../StellarisWare/utils/: ustdlib.c
  group External
    ../RASLib/Debug/: raslib.lib
    ../StellarisWare/driverlib/rvmdk/: driverlib.lib
    ../StellarisWare/utils/: uartstdio.c
  group Main
    ./: Startup.s PC_uC_Interface.c
  group headers
    ./: definitions.h message_processor.h UART_Functions.h Nunchuck_Functions.h time_functions.h motor_functions.h settings.h adc_functions.h gpio_functions.h utils.h sorted_buf.h filtering_functions.h common.h
    ../StellarisWare/utils/: ustdlib.h
